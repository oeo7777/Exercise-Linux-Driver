## hello_device/Kconfig
```kconfig
Kconfig

config HELLO_DRIVER
    default y
    tristate "Hello Driver"
    help
      Say Y here if you want to enable hello driver.
```
